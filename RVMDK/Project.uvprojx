# Keil uVision project Project.uvprojx, settings and files
target Project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User\bsp
  memory RVCT4: ROM 0x8000000 size 0x3c00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: main.c stm32f10x_it.c upload.c ymodem.c common.c download.c
    ../User/bsp/: bsp_tm1639.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../User/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
software components: CMSIS:CORE 4.3.0
